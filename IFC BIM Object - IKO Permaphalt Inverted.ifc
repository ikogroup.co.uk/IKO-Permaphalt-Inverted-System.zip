Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2025-08-26T09:10:44
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Basic Roof:NBS_IKOUK_RoofingTankingAndFlooringMasticAsphaltMA_IKOPermaphaltInvertedMasticAsphaltRoofingSystem-HeritageProjectFriendly_IKOPermaphaltBlock-4180000, Basic Roof:NBS_IKOUK_RoofingTankingAndFlooringMasticAsphaltMA_IKOPermaphaltInvertedMasticAsphaltRoofingSystem-HeritageProjectFriendly_IKOPermaphaltBlock-4180000:221903
In: Level 0
Type - PredefinedType: USERDEFINED
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: USERDEFINED
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_35_31_05_72:Roofing, tanking and flooring mastic asphalt (MA); Color: n/a; Finish: n/a; Material: Asphalt,Polymer; Shape: n/a; Size: n/a; WarrantyDescription: 25 year; CodePerformance: n/a; Constituents: n/a; Description: Polymer-modified mastic asphalt roofing and waterproofing system.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: marketing.uk@iko.com; ModelNumber: n/a; ModelReference: IKO Permaphalt Inverted Mastic Asphalt Roofing System - Heritage Project Friendly; Name: RoofingTankingAndFlooringMasticAsphaltMA_IKOPermaphaltInvertedMasticAsphaltRoofingSystem-HeritageProjectFriendly_IKOPermaphaltBlock-4180000_IKOUK; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_IKOUK_RoofingTankingAndFlooringMasticAsphaltMA_IKOPermaphaltInvertedMasticAsphaltRoofingSystem-HeritageProjectFriendly_IKOPermaphaltBlock-4180000; ManufacturerName: IKO UK; ManufacturerURL: https://ikogroup.co.uk/; ProductInformation: https://source.thenbs.com/product/-/6d585142-caf1-8b91-0680-2350447d3d0a/3bc5834d-7f6d-4a24-9334-11e56753f245; Uniclass2015Code: Pr_35_31_05_72; Uniclass2015Title: Roofing, tanking and flooring mastic asphalt (MA); Uniclass2015Version: Products v1.37; Version: 16
Type - NBS_Data - Colour: Black; CountryOfMaterialOrigin: United Kingdom; CountryOfProductManufacture: United Kingdom; Durability: Capable of lasting 50-60 years; Expansion: Coefficient of cubic expansion: 15 x 10^-5/°C; ManufacturingPlantLocation: Prospect Quarry, Grangemill, Matlock DE4 4BW, UK; Mass: 2.2 kg/m²/mm of thickness; MasticAsphaltGradeOfAsphalticCement: Polymer modified; MasticAsphaltStandard: To BS EN 12970; MasticAsphaltType: Block (20 kg); Movement: IKO Permaphalt is thermoplastic and is capable of accommodating normal movements encountered in well-designed building structures; ResistanceToFire: To EN 13501-5, Broof(t4); SurfaceProtection: With the exception of vertical and steeply sloping work, the finished IKO Permaphalt must be sand rubbed to reduce the incidence of crazing. A protective surface should be applied to all flat areas using a suitable solar reflective paint, stone chippings or promenade surfacing; ThicknessOptions: 20 mm,30 mm; ThirdPartyCertification: British board of agrement: 89/2299; VapourResistivity: Not less than 100,000 MN/g; WaterResistance: IKO Permaphalt is impervious to water
Classification: Pr_35_31_05_72 (Uniclass2015); Material: NBS_IKOUK_RoofingTankingAndFlooringMasticAsphaltMA_IKOPermaphaltInvertedMasticAsphaltRoofingSystem-HeritageProjectFriendly_IKOPermaphaltBlock-4180000 20 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Basic Roof:NBS_IKOUK_RoofingTankingAndFlooringMasticAsphaltMA_IKOPermaphaltInvertedMasticAsphaltRoofingSystem-HeritageProjectFriendly_IKOPermaphaltHotCharge-5180000, Basic Roof:NBS_IKOUK_RoofingTankingAndFlooringMasticAsphaltMA_IKOPermaphaltInvertedMasticAsphaltRoofingSystem-HeritageProjectFriendly_IKOPermaphaltHotCharge-5180000:222085
In: Level 0
Type - PredefinedType: USERDEFINED
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: USERDEFINED
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_35_31_05_72:Roofing, tanking and flooring mastic asphalt (MA); Color: n/a; Finish: n/a; Material: Asphalt,Polymer; Shape: n/a; Size: n/a; WarrantyDescription: 25 year; CodePerformance: n/a; Constituents: n/a; Description: Polymer-modified mastic asphalt roofing and waterproofing system.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: marketing.uk@iko.com; ModelNumber: n/a; ModelReference: IKO Permaphalt Inverted Mastic Asphalt Roofing System - Heritage Project Friendly; Name: RoofingTankingAndFlooringMasticAsphaltMA_IKOPermaphaltInvertedMasticAsphaltRoofingSystem-HeritageProjectFriendly_IKOPermaphaltHotCharge-5180000_IKOUK; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_IKOUK_RoofingTankingAndFlooringMasticAsphaltMA_IKOPermaphaltInvertedMasticAsphaltRoofingSystem-HeritageProjectFriendly_IKOPermaphaltHotCharge-5180000; ManufacturerName: IKO UK; ManufacturerURL: https://ikogroup.co.uk/; ProductInformation: https://source.thenbs.com/product/-/6d585142-caf1-8b91-0680-2350447d3d0a/3bc5834d-7f6d-4a24-9334-11e56753f245; Uniclass2015Code: Pr_35_31_05_72; Uniclass2015Title: Roofing, tanking and flooring mastic asphalt (MA); Uniclass2015Version: Products v1.37; Version: 16
Type - NBS_Data - Colour: Black; CountryOfMaterialOrigin: United Kingdom; CountryOfProductManufacture: United Kingdom; Durability: Capable of lasting 50-60 years; Expansion: Coefficient of cubic expansion: 15 x 10^-5/°C; ManufacturingPlantLocation: Prospect Quarry, Grangemill, Matlock DE4 4BW, UK; Mass: 2.2 kg/m²/mm of thickness; MasticAsphaltGradeOfAsphalticCement: Polymer modified; MasticAsphaltStandard: To BS EN 12970; MasticAsphaltType: Hot charge; Movement: IKO Permaphalt is thermoplastic and is capable of accommodating normal movements encountered in well-designed building structures; ResistanceToFire: To EN 13501-5, Broof(t4); SurfaceProtection: With the exception of vertical and steeply sloping work, the finished IKO Permaphalt must be sand rubbed to reduce the incidence of crazing. A protective surface should be applied to all flat areas using a suitable solar reflective paint, stone chippings or promenade surfacing; ThicknessOptions: 20 mm,30 mm; ThirdPartyCertification: British board of agrement: 89/2299; VapourResistivity: Not less than 100,000 MN/g; WaterResistance: IKO Permaphalt is impervious to water
Classification: Pr_35_31_05_72 (Uniclass2015); Material: NBS_IKOUK_RoofingTankingAndFlooringMasticAsphaltMA_IKOPermaphaltInvertedMasticAsphaltRoofingSystem-HeritageProjectFriendly_IKOPermaphaltHotCharge-5180000 20 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
